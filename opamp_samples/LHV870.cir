*  LHV870
*****************************************************************************
* (C) COPYRIGHT 2012 TEXAS INSTRUMENTS INCORPORATED. ALL RIGHTS RESERVED.
*****************************************************************************
** THIS MODEL IS DESIGNED AS AN AID FOR CUSTOMERS OF TEXAS INSTRUMENTS.
** TI AND ITS LICENSORS AND SUPPLIERS MAKE NO WARRANTIES, EITHER EXPRESSED
** OR IMPLIED, WITH RESPECT TO THIS MODEL, INCLUDING THE WARRANTIES OF
** MERCHANTABILITY OR FITNESS FOR A PARTICULAR PURPOSE.  THE MODEL IS
** PROVIDED SOLELY ON AN "AS IS" BASIS.  THE ENTIRE RISK AS TO ITS QUALITY
** AND PERFORMANCE IS WITH THE CUSTOMER.
*****************************************************************************
*
** RELEASED BY: ANALOG ELAB DESIGN CENTER, TEXAS INSTRUMENTS INC.
* DATE:             2012-02-29
* MODEL TYPE:       ALL IN ONE
* SIMULATOR:        TINA
* SIMULATOR VERSION: VERSION 9.1.30.94 SF
* DATASHEET:        MAY 25, 2011
* EVM ORDER NUMBER: N/A
* EVM USERS GUIDE:  N/A
* MODEL VERSION:    1.0
*
*****************************************************************************
*
* UPDATES:
*
* VERSION 1.0 :
* RELEASE TO WEB
*
*****************************************************************************
* NOTES:
* THE LHV870 MACRO MODEL REPRESENTS THE FOLLOWING PARAMETERS FOR
* SINGLE-SUPPLY OPERATION (+/-22V):
* GBWP, INPUT-REFERRED VOLTAGE NOISE, THE QUIESCENT CURRENT,
* OUTPUT SWING, INPUT OFFSET VOLTAGE, INPUT BIAS CURRENT, PSRR,
* CMRR, AND THE SLEW RATE.
*
*****************************************************************************
*
*****************************************************************************
*$
.SUBCKT LHV870_0  INP INN VCC  VEE OUT
*X_UGND       VCC   0    VEE   0    GND_FLOAT 0  EPOLY2 PARAMS: COEFF1=0.5 COEFF2=0.5
RGN1          0          GND_FLOAT  100MEG
EVCVSGN1      GND_FLOAT  0    32    0  1
EVCVSGN2      33         0    VCC   0  1
EVCVSGN3      31         0    VEE   0  1
CGN1          32         0    1
XRGN2         32         33   RNOISELESS  PARAMS: ROHMS=1E6
XRGND3        31         32   RNOISELESS  PARAMS: ROHMS=1E6
*
X_U9          VCC  VEE   PD   VIMON GND_FLOAT INP2 INN1 HPA_PD_I PARAMS: VTH=1.4
+  IMAX=4.8E-3 IMIN=3N IIBP=10N IIBN=10.1N

V_VOS         INP2       INP_CMRR   56.0UVDC
C_CINP        GND_FLOAT  INP1       600F  TC=0,0
C_CINN        GND_FLOAT  INN1       600F  TC=0,0
R_RINP        INP        INP1       1     TC=0,0
R_RINN        INN        INN1       1     TC=0,0
X_U12         INP1       INP2       VNSE
X_UCN         INP1       INN1       FEMT

V_V1          VCC        N3310020   1.62VDC
V_V4          N3310060   VEE        1.84VDC
X_UD1         INP_CMRR   N3310020   D_IDEAL
X_UD2         INN3       N3310020   D_IDEAL
X_UD3         N3310060   INP_CMRR   D_IDEAL
X_UD4         N3310060   INN3       D_IDEAL

X_UG0         INP_CMRR   INN3 GND_FLOAT    AV1     VCCS_LIMIT PARAMS: GAIN=10E-6
+  IPOS=0.5 INEG=-0.5
X_UG4         AV1   GND_FLOAT GND_FLOAT OVER_CLAMP VCCS_LIMIT PARAMS: GAIN=172.8U
+  IPOS=98U INEG=-95.5U
X_U1          GND_FLOAT  AV1        RNOISELESS PARAMS: R=1E6
X_U2          GND_FLOAT  OVER_CLAMP RNOISELESS PARAMS: R=5.8E9

E_E1          VCC_BUF    GND_FLOAT  VCC GND_FLOAT 1
E_E2          VEE_BUF    GND_FLOAT  VEE GND_FLOAT 1

C_CC1         GND_FLOAT  OVER_CLAMP 5P        TC=0,0
C_CC2         P0ZP1      GND_FLOAT  723.4E-18 TC=0,0
C_CC3         CLAW_CLAMP GND_FLOAT  144.7F    TC=0,0
C_CC4         GND_FLOAT  GND_FLOAT  4.11F     TC=0,0

R_R4          VCC        PD         1E-3 TC=0,0
G_G3          GND_FLOAT  VSENSE     OVER_CLAMP GND_FLOAT 1U
G_G4          GND_FLOAT  P0Z        VSENSE     GND_FLOAT 1U
G_G5          GND_FLOAT  P0ZP1      P0Z        GND_FLOAT 1U
G_G6          GND_FLOAT  CLAW_CLAMP P0ZP1      GND_FLOAT 1M
G_G7          GND_FLOAT  CL_CLAMP   CLAW_CLAMP GND_FLOAT 1M

X_U3          VSENSE     GND_FLOAT  RNOISELESS PARAMS: R=1E6
X_U5          GND_FLOAT  P0Z        RNOISELESS PARAMS: R=1E6
X_U6          P0ZP1      GND_FLOAT  RNOISELESS PARAMS: R=1E6
X_U7          CLAW_CLAMP GND_FLOAT  RNOISELESS PARAMS: R=1E3
X_U8          CL_CLAMP   GND_FLOAT  RNOISELESS PARAMS: R=1E3

G_G1          GND_FLOAT  N3309274   INP_CMRR   GND_FLOAT 1U
E_ECMRR       INN2 INN3  N3309274   GND_FLOAT 1
R_RCMR        N3309274   N33089240  1 TC=0,0
L_LCMR        N33089240  GND_FLOAT  560NH

G_G2          GND_FLOAT  N3309420   VCC        VEE       1U
X_UPSRR       N3309420   GND_FLOAT  INN1 INN2 VCVS_LIMIT PARAMS: GAIN=-1
+  VPOS=20M VNEG=-20M
R_RPSR        N3309420   N33093920  1 TC=0,0
L_LPSR        N33093920  GND_FLOAT  2UH

C_UCL_CCL2    GND_FLOAT  UCL_N01226 1P  TC=0,0
C_UCL_CCL1    UCL_N01131 GND_FLOAT  1P  TC=0,0
V_UCL_VCLP    UCL_N00774 GND_FLOAT  53VDC
V_UCL_VCLN    UCL_N00760 GND_FLOAT -42VDC
X_UCL_UCL1    UCL_N50037 UCL_N01131 D_IDEAL
X_UCL_UCL2    UCL_N01226 UCL_N50037 D_IDEAL
E_UCL_E1      UCL_N01131 GND_FLOAT  UCL_N00774 VIMON 100
E_UCL_E2      UCL_N01226 GND_FLOAT  UCL_N00760 VIMON 100
R_UCL_RCL1    UCL_N01131 SC_P       1 TC=0,0
R_UCL_RCL2    SC_N       UCL_N01226 1 TC=0,0
R_UCL_RCL3    UCL_N50037 CL_CLAMP   0.01 TC=0,0

V_UVCL_VCLO1  VCC         UVCL_N498931 7.10VDC
V_UVCL_VCLO2  UVCL_N50894 VEE          7.10VDC
X_UVCL_UVCL1  OVER_CLAMP  UVCL_N498931 D_IDEAL
X_UVCL_UVCL2  UVCL_N50894 OVER_CLAMP   D_IDEAL

R_R3          GND_FLOAT  SC_P       1G   TC=0,0
R_R3A         GND_FLOAT  SC_N       1G   TC=0,0
R_R2          GND_FLOAT  OL_P       1G   TC=0,0
R_R2A         GND_FLOAT  OL_N       1G   TC=0,0

X_UZ_S1       OL_P       GND_FLOAT  UZ_N45387 UZ_VZO_3 ZOUT_UZ_S1
X_UZ_S2       OL_N       GND_FLOAT  UZ_N45507 UZ_VZO_3 ZOUT_UZ_S2
R_UZ_RA       UZ_N45387  UZ_VZO_4   10 TC=0,0
R_UZ_RB       UZ_N45507  UZ_VZO_4   10 TC=0,0
R_UZ_RM       UZ_VZO_3   UZ_VZO_4   10 TC=0,0
X_UZ_UAMP1    VCLP       UZ_N36964  UZ_VZO_1 GND_FLOAT VCVS_LIMIT PARAMS:
+  GAIN=1E6 VPOS=6E4 VNEG=-6E4
X_UZ_UAMP2    GND_FLOAT  UZ_N37614  UZ_VZO_3 GND_FLOAT VCVS_LIMIT PARAMS:
+  GAIN=1E6 VPOS=6E4 VNEG=-6E4
E_UZ_E1       UZ_VZO_2   GND_FLOAT  UZ_VZO_1 UZ_VZO_4 -1
X_UZ_RG1      GND_FLOAT  UZ_N36964  RNOISELESS PARAMS: R=10E6
X_UZ_RF1      UZ_N36964  UZ_VZO_1   RNOISELESS PARAMS: R=10E6
X_UZ_RG2      UZ_VZO_2   UZ_N37614  RNOISELESS PARAMS: R=1E6
X_UZ_RF2      UZ_N37614  UZ_VZO_3   RNOISELESS PARAMS: R=1E6
X_UZ_H1       UZ_VZO_4   OUT VIMON  GND_FLOAT ZOUT_UZ_H1

X_UTHD        N3309236   GND_FLOAT  VCLP GND_FLOAT EPOLY1
*+PARAMS: COEFF1=0.0   COEFF2=0.0

X_U10         CL_CLAMP   GND_FLOAT  PD N3309236 GND_FLOAT VCC VEE HPA_PD_SGNL
+  PARAMS: GAIN=1
X_U11         VCC VEE VIMON GND_FLOAT TRAN_IOUT
.ENDS LHV870_0
